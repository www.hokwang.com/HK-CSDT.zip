Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: HK-CSDT.IFC
Time: 2022-01-04T03:15:31
Written by: SwIFC
Made in: SolidWorks 2021

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: <出口轉接頭>-<除料-伸長1>
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: A0130-0029_HK-CSDX3_轉角接頭
In: Default Storey
PredefinedType: ELEMENT; Material: PP 單聚物

# IfcBuildingElementProxy: A0130-0037_HK-CSDX3_皂液出皂口
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: A0130-0065 HK-CSDT_填皂口蓋
In: Default Storey
PredefinedType: ELEMENT; Material: PP 單聚物

# IfcBuildingElementProxy: A0130-0066 HK-CSDT_主體填皂管
In: Default Storey
PredefinedType: ELEMENT; Material: PP 共聚物

# IfcBuildingElementProxy: A0130-0068 HK-CSDT_感應器護蓋_A1
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: C0330-0008 HK-CSDT_主體填皂管鎖附片
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: C0330-0010 HK-CSDT_¤£ù×¿ûµØ¥q
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: D0230-0001 HK-CSDT_長螺帽
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: F0330-0008 HK-CSDT_感應器基板組
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: G0130-0020 HK-CSDT_橡膠華司(上)
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: K0130-0009 HK-CSDT_上方銘版
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: 填料-伸長3
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 除料-伸長4
In: Default Storey
PredefinedType: ELEMENT
